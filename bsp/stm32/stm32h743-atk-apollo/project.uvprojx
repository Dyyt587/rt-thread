# Keil uVision project project.uvprojx, settings and files
target rtthread (6210000::V6.21::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32H743xx, __perf_counter_printf__=rt_kprintf, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __PERF_CNT_USE_RTOS__, __RTTHREAD__
  c include: packages\CherryUSB-latest\class\video;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;packages\ST7789;..\..\..\components\utilities\libadt\ref;packages\CherryUSB-latest\class\hid;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\usbdevice;packages\CMSIS_RTOS2-latest;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\delay;packages\CherryUSB-latest\class\wireless;packages\get_irq_priority-latest;packages\aUnity-latest\afifo;..\..\..\components\libc\posix\io\epoll;packages\CherryUSB-latest\class\dfu;packages\aUnity-latest;..\..\..\components\libc\posix\io\eventfd;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\utilities\libadt\bitmap;packages\CMSIS_5-v5.9.0\CMSIS\RTOS2\Include;..\..\..\components\libc\cplusplus\cpp11\armclang;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\CherryUSB-latest\core;..\..\..\components\utilities\libadt\avl;..\..\..\components\libc\posix\ipc;packages\cpu_usage-latest;packages\aUnity-latest\alist;.;..\..\..\components\drivers\include;packages\CherryUSB-latest\class\midi;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\cortex-m7;..\libraries\HAL_Drivers\CMSIS\Include;board;..\..\..\components\drivers\include;packages\aUnity-latest\acheck;packages\perf_counter-v2.2.4.1;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\utilities\ulog;..\..\..\components\drivers\include;packages\CherryUSB-latest\class\msc;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers\drivers\drv_flash;packages\CherryUSB-latest\class\cdc;packages\CherryUSB-latest\osal;..\libraries\HAL_Drivers\drivers;packages\CherryUSB-latest\class\vendor\serial;..\..\..\components\drivers\spi\sfud\inc;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\components\utilities\libadt\hashmap;..\..\..\components\libc\cplusplus;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\cplusplus\os;packages\CherryUSB-latest\class\vendor\net;..\..\..\components\drivers\include;..\..\..\components\drivers\ktime\inc;..\..\..\components\drivers\include;packages\sys_load_monitor-v1.0.0;packages\CherryUSB-latest\common;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;board\ports;packages\aUnity-latest\cvector;..\..\..\components\utilities\libadt\uthash;packages\CherryUSB-latest\class\audio;..\..\..\components\drivers\ktime;..\..\..\components\libc\posix\io\stdio;..\libraries\HAL_Drivers;..\..\..\components\libc\posix\pthreads;packages\CMSIS_5-v5.9.0\CMSIS\Core\Include;..\..\..\libcpu\arm\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./packages/CherryUSB-latest/demo/: cdc_acm_template.c
    ./packages/CherryUSB-latest/class/cdc/: usbd_cdc.c
    ./packages/CherryUSB-latest/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
  group aUnity
    packages/aUnity-latest/cvector/: cvector.c
    packages/aUnity-latest/acheck/: all_check.c
    packages/aUnity-latest/afifo/: afifo.c
  group CherryUSB
    packages/CherryUSB-latest/third_party/rt-thread-5.0/: usb_check.c usb_msh.c
    packages/CherryUSB-latest/osal/: usb_osal_rtthread.c
    packages/CherryUSB-latest/core/: usbd_core.c
  group CMSIS-RTOS2
    packages/CMSIS_RTOS2-latest/: cmsis_rtthread.c os_systick.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    ../../../components/libc/cplusplus/cpp11/armclang/: clock.cpp condvar.cpp miscellaneous.cpp mutex.cpp thread.cpp
    ../../../components/libc/cplusplus/cpp11/: atomic_8.c emutls.c thread_local_impl.cpp
    ../../../components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
    ../../../components/libc/cplusplus/os/: cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp
  group cpu_usage
    packages/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial_v2.c
    ../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_lcd.c drv_qspi.c drv_sdram.c drv_spi.c drv_usart_v2.c
    ../libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_h7.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c drv_mpu.c
    board/ports/: drv_qspi_flash.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group get_irq_priority
    packages/get_irq_priority-latest/src/: get_irq.c
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group ktime
    ../../../components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group LIBADT
    ../../../components/utilities/libadt/avl/: avl.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_pcd.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_ll_usb.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_hcd.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
    packages/perf_counter-v2.2.4.1/: perf_counter.c
  group POSIX
    ../../../components/libc/posix/delay/: delay.c
    ../../../components/libc/posix/io/stdio/: stdio.c
    ../../../components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group st7789
    packages/ST7789/: lcd_st7789.c
  group sys_load_monitor
    packages/sys_load_monitor-v1.0.0/: sys_load_monitor.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/: ulog.c
