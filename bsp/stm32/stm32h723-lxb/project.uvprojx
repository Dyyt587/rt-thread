# Keil uVision project project.uvprojx, settings and files
target rtthread (6210000::V6.21::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, STM32H723xx
  c include: ..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\components\utilities\ulog;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\..\components\drivers\ktime;..\..\..\components\libc\posix\io\stdio;board;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\ktime\inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\pthreads;..\..\..\include;..\..\..\components\drivers\usb\cherryusb\class\cdc;.;..\..\..\components\drivers\usb\cherryusb\class\vendor\net;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\libc\posix\delay;..\..\..\components\drivers\usb\cherryusb\class\audio;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\tls;..\..\..\components\legacy;applications;..\..\..\components\drivers\usb\cherryusb\class\hid;..\..\..\components\drivers\usb\cherryusb\core;..\libraries\HAL_Drivers;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\usb\cherryusb\common;..\..\..\components\drivers\usb\cherryusb\class\wireless;..\..\..\components\drivers\usb\cherryusb\class\dfu;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\usb\cherryusb\class\msc;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\smp;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\components\drivers\usb\cherryusb\osal;board\CubeMX_Config\Core\Inc;..\..\..\components\legacy\dfs;..\..\..\components\drivers\usb\cherryusb\class\vendor\serial
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CherryUSB
    ../../../components/drivers/usb/cherryusb/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
    ../../../components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usb_msh.c
    ../../../components/drivers/usb/cherryusb/core/: usbd_core.c
    ../../../components/drivers/usb/cherryusb/demo/: cdc_acm_template.c
    ../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../../../components/drivers/usb/cherryusb/class/cdc/: usbd_cdc_acm.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h723xx.s
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group ktime
    ../../../components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_mdma.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_sram.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cec.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rtc.c stm32h7xx_hal.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_dma_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group POSIX
    ../../../components/libc/posix/delay/: delay.c
    ../../../components/libc/posix/io/stdio/: stdio.c
    ../../../components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
    ../../../components/libc/posix/tls/: emutls.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
