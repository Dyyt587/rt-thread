# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_ARMLIBC, CORE_CM7, STM32H747xx, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_LIBC, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension\fcntl\octal;applications;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\libraries\HAL_Drivers\drivers;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;board\CubeMX_Config\CM7\Inc;..\..\..\components\libc\compilers\common\include;.;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\finsh;..\..\..\components\libc\posix\io\eventfd;board;..\..\..\include;..\libraries\HAL_Drivers;..\..\..\libcpu\arm\cortex-m7;..\libraries\HAL_Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
    board/CubeMX_Config/CM7/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c msh.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cec.c stm32h7xx_hal_rcc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_cryp.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_pwr.c stm32h7xx_hal_cortex.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_comp.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
target Target_CM4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\board\linker_scripts\link.sct
