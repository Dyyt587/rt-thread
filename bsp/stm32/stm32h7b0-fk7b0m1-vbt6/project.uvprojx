# Keil uVision project project.uvprojx, settings and files
target rt-thread (6210000::V6.21::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3
  c define: __PERF_CNT_USE_RTOS__, USE_HAL_DRIVER, STM32H7B0xx, RT_USING_LIBC, __perf_counter_printf__=rt_kprintf, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: packages\aUnity-latest\cvector;packages\aUnity-latest\afifo;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\dfs\dfs_v1\filesystems\devfs;applications;board\port;..\libraries\HAL_Drivers\drivers;packages\perf_counter-v2.2.4.1;..\..\..\components\legacy\dfs;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension;packages\aUnity-latest\acheck;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\HAL_Drivers\drivers\config;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\components\utilities\ulog;packages\APID-latest\src;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\include;..\..\..\components\legacy;..\..\..\components\finsh;applications\motor;..\libraries\HAL_Drivers\CMSIS\Include;..\libraries\HAL_Drivers;.;..\..\..\include;..\..\..\components\libc\posix\io\poll;packages\aUnity-latest;..\..\..\components\libc\posix\io\eventfd;packages\aUnity-latest\alist;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
  group apid
    packages/APID-latest/src/: apid.c apid_auto_tune_ZNmode.c apid_exfunc.c apid_ex_fuzzy.c
  group Applications
    applications/: main.c
    applications/motor/: Trajectory_planning.c motor.c motor_cfg.c motor_dj_rm_driver.c motor_mit_driver.c motor_planning.c
  group aUnity
    packages/aUnity-latest/acheck/: all_check.c
    packages/aUnity-latest/cvector/: cvector.c
    packages/aUnity-latest/afifo/: afifo.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial_v2.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h7b0xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_fdcan.c drv_gpio.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c msh_file.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c memheap.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc.c stm32h7xx_hal_rng.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rcc.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cryp.c stm32h7xx_hal_uart.c stm32h7xx_hal_dma.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_comp.c stm32h7xx_hal_pwr.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/: perf_counter.c
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/: ulog.c
